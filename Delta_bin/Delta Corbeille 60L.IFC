Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Delta Corbeille 60L.IFC
Time: 2020-07-01T11:04:16
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: DELT-COR-60-003_Default
In: Default Storey
PSet_Mass_Property - Mass Measure: 43.76; Area Measure: 5.40367; Volume Measure: 0.012059

# IfcBuildingElementProxy: DELT-COR-60-011_Default
In: Default Storey
Material: FGS 400-15

# IfcBuildingElementProxy: MULT-BAC-COR-001_Default
In: Default Storey
Material: PE

# IfcBuildingElementProxy: MULT-SCE-001_Default (3)
In: Default Storey
Material: S235
